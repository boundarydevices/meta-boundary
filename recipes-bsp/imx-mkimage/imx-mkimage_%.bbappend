SRCBRANCH = "boundary-imx_4.9.123_imx8mm_ga"
SRC_URI = "git://github.com/boundarydevices/imx-mkimage.git;branch=${SRCBRANCH}"
SRCREV = "${AUTOREV}"
PV = "1.0+git${SRCPV}"
