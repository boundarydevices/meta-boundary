SRCBRANCH = "ezurio-lf-6.6.52-2.2.0"
SRC_URI = "git://github.com/boundarydevices/imx-atf.git;branch=${SRCBRANCH};protocol=https"
SRCREV = "400e5e4b5407803b9401a2f4f1ccd8c42e7c6d8b"
