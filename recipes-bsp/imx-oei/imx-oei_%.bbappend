SRCBRANCH = "ezurio-lf-6.12.20-2.0.0"
SRC_URI = "git://github.com/boundarydevices/imx-oei.git;branch=${SRCBRANCH};protocol=https"
SRCREV = "578b1aada4292c17787ff1378cb2770f208673ba"
