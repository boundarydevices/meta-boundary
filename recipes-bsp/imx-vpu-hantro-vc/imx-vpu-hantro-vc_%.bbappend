COMPATIBLE_MACHINE = "(nitrogen8mp)"
