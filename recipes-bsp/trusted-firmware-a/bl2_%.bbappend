FILESEXTRAPATHS:append := "${THISDIR}/files:"
SRC_URI:append = " file://0002-BL2-mediatek-Change-UART_BAUDRATE-to-115200.patch \
		   file://0003-trusted-firmware-a-Use-LOG_LEVEL_ERROR-for-Release-b.patch \
"
