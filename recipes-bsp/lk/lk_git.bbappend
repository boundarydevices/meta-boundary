FILESEXTRAPATHS:append := "${THISDIR}/files:"
SRC_URI:append = " file://0001-mt8188-Default-baud-rate-for-Tungsten-is-115200.patch \
		   file://0002-mt8188-Use-define-for-debug-baud-rate.patch \
"
