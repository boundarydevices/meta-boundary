SRCBRANCH = "ezurio-lf-6.6.52-2.2.0"
SRC_URI = "git://github.com/boundarydevices/imx-sm.git;branch=${SRCBRANCH};protocol=https"
SRCREV = "0d442d1fe17a56c7f9879ce98a7745605f32e5e8"
