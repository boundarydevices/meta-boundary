#This class is need for chromium-gn.inc
inherit distro_features_check
