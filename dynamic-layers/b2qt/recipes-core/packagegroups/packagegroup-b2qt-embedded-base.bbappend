RDEPENDS:${PN}:remove = "linux-firmware"
