FILESEXTRAPATHS:prepend:mx6-nxp-bsp := "${THISDIR}/boundary:"
FILESEXTRAPATHS:prepend:mx7-nxp-bsp := "${THISDIR}/boundary:"
FILESEXTRAPATHS:prepend:mx8-nxp-bsp := "${THISDIR}/boundary:"
