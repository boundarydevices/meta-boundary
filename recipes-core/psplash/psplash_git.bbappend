FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGES = "file://ezurio-logo-img.h;outsuffix=default"
