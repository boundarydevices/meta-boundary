PACKAGECONFIG:append = " kms"
