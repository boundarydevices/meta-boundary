SRC_URI:remove = "git://git.alsa-project.org/tinycompress.git;protocol=git;branch=master"
SRC_URI:prepend = "git://github.com/alsa-project/tinycompress.git;protocol=https;branch=master "
