CXXFLAGS += " -Wno-error=uninitialized"
