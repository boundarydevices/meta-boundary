FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append += "file://0001-print-javascript-console-messages-to-stderr.patch "
