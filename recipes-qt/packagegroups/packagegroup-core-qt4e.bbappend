RDEPENDS_${PN}_remove = "qt-demo-init"
