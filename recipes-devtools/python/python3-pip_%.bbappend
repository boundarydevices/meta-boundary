FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-factory.py-disable-unsupported-wheel-checks.patch"
