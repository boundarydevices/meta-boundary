PACKAGECONFIG_append_mx6 = " osmesa"
DRIDRIVERS_append_mx6 = "swrast"
PACKAGECONFIG_remove_mx6 = "gallium"
