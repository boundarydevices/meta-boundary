FILESEXTRAPATHS_append  := "${THISDIR}/files:"

SRC_URI_append = "file://Revert_gl_Add_support_for_OpenGL_ES_3.0.patch \
		  file://0005-Makefile.am.features.patch"
