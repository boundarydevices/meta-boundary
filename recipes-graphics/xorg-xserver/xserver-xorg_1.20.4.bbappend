FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-v2-xserver-xorg-Fix-X-server-crash.patch"

