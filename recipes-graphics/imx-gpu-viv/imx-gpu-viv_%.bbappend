PACKAGES_OPENVX += "libopenvx-imx libopenvx-imx-dev"
