# Get rid of connman
NETWORK_MANAGER = "networkmanager"
